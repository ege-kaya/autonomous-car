# Keil uVision project LAB_001.uvprojx, settings and files
target LPC4088FET208 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_001 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
